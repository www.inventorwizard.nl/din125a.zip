# Autodesk Inventor part: Din125 A
## iProperties
Created: 2006-04
Part Number: Din125 A
Document SubType Name: Modeling
Designer: John Tillema
Author: John Tillema
## Feature names
1. Extrusion1
